require linux-yocto-intel-x86.inc

KBRANCH:intel-x86  = "v6.6/standard/x86"

LINUX_VERSION:intel-x86 ?= "6.6.x"
